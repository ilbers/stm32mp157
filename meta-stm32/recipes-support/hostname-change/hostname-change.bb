# Copyright (C) 2024 ilbers GmbH

SRC_URI = "file://postinst"

inherit dpkg-raw
