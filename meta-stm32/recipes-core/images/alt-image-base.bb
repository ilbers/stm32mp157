# Copyright (C) 2024 ilbers GmbH

require recipes-core/images/isar-image-base.bb

DESCRIPTION = "Alternative target filesystem"

PREFERRED_VERSION_tstpkg:stm32mp157 = "2.0"
